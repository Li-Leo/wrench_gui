# Keil uVision project LK_StdPeriph.uvproj, settings and files
target BLDC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC03x Linko
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(48000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: torque_wrench +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  .\firmware\torque_wrench.bin .\Obj\*.axf
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Source;.\LKS32MC03x_Periph_Driver;.\LKS32MC03x_Periph_Driver\include;.\Include;.\Source\simple_gui\GUI\inc;.\Source\simple_gui\HMI\inc;.\Source\simple_gui\usr_screen\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source code
    ./Source/: main.c interrupt.c hardware_init.c Global_Variable.c oled.c
    ./Source/key/: flexible_button.c key.c
  group MCU_Driver
    ./LKS32MC03x_Periph_Driver/Source/: lks32mc03x_gpio.c lks32mc03x_I2C.c lks32mc03x_sys.c lks32mc03x_timer.c lks32mc03x_uart.c lks32mc03x_nvr.lib delay.c lks32mc03x_IWDG.c
    ./Include/: startup_lks32mc03x.s
  group SGUI
    ./Source/simple_gui/GUI/src/: SGUI_Basic.c SGUI_Common.c SGUI_IconResource.c SGUI_Interface.c SGUI_ItemsBase.c SGUI_List.c SGUI_Menu.c SGUI_Notice.c SGUI_ScrollBar.c SGUI_Text.c
    ./Source/simple_gui/HMI/src/: HMI_Engine.c
  group user_gui
    ./Source/simple_gui/usr_screen/src/: extended_list.c font_data.c inconsolata_bold_20.c inconsolata_regular_16.c list_demo.c screen_proc.c settings_list.c inconsolata_regular_12.c
